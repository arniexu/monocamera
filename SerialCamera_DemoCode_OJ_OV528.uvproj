# Keil uVision project SerialCamera_DemoCode_OJ_OV528.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SerialCamera_DemoCode_OJ_OV528
  AfterMake: fromelf --bin -o build\SerialCamera_DemoCode_OJ_OV528_LPC1768.bin build\SerialCamera_DemoCode_OJ_OV528.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: TARGET_LPC1768,  TARGET_M3,  TARGET_CORTEX_M,  TARGET_NXP,  TARGET_LPC176X,  TARGET_MBED_LPC1768,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1428243125.23,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;mbed;mbed/TARGET_LPC1768;mbed/TARGET_LPC1768/TARGET_NXP;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X;mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768;mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;SDFileSystem;SDFileSystem/FATFileSystem;SDFileSystem/FATFileSystem/ChaN;.\serial_camera;.\EaEpaper;.\BMPFile;.\joystick;.\BaseJpegDecode;.\SimpleJpegDecode;.\Thermal;.\Adafruit_Thermal
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/system_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
            
              mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
    SDFileSystem/: SDFileSystem.cpp
    SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATFileHandle.cpp FATFileSystem.cpp
    SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp ff.cpp diskio.cpp
  group serial camera kit
    ./serial_camera/: serial_camera.cpp
  group debug
    ./: debug.cpp
  group epaper
    ./EaEpaper/: EaEpaper.cpp GraphicsDisplay.cpp TextDisplay.cpp EPD.cpp
    ./: disbuffer.cpp
  group joystick
    ./: joystick.cpp
  group imageprocessor
    ./: imageprocessor.cpp
  group bmpfile
    ./BMPFile/: BMPFile.cpp
  group command
    ./: command.cpp
  group SimpleJpegDecode
    ./SimpleJpegDecode/: SimpleJpegDecode.cpp
  group BaseJpegDecode
    ./BaseJpegDecode/: aanIDCT.cpp BaseJpegDecode.cpp BitPattern.cpp HuffmanDecode.cpp inverseDCT.cpp
  group thermal
    ./Thermal/: Thermal.cpp
  group adafruit_thermal
    ./Adafruit_Thermal/: Adafruit_Thermal.cpp
